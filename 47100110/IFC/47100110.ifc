Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: X:\Work\Ostnor\Projekt\Projekt 2013\20130508_CAD-objekt\Arbetsmapp\47100110\AutoCAD Architecture\47100110.ifc
Time: 2013-06-11T10:25:33
Author: - -
Organization: FM Mattsson, Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 47100110
LongName: 47100110
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 47100110
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 47100110, BUILDINGELEMENTPROXY(1)
In: 47100110
Description: FM Mattsson, Tidan Kitchen Mixer, model 47100110
